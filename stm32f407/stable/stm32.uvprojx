# Keil uVision project stm32.uvprojx, settings and files
target target main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,STM32F40_41xxx, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, HSE_VALUE = 12000000
  c include: .\src\main;.\src\cmsis;.\src\spl4;.\src\spl4\inc;.\src\spl4\src;.\src\external;.\src\global_macros;.\src\support_pacage;.\src\support_pacage\arm;.\src\support_pacage\gcc;.\src\support_pacage\inc;.\src\pin_setup;.\src\time_service;.\src\adc;.\src\dma;.\src\usart6;.\src\soft;.\src\IRLocator;.\src\motor;.\src\motor_pin_setup;.\src\motors;.\src\line_sensors;.\src\usart3;.\src\OpenMV;.\src\dma;.\src\math;.\src\my_math;.\src\PID;.\src\spl4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/main/: RTE_Device.h startup_stm32f407xx.s project_config.h
    ./src/support_pacage/: system_stm32f4xx.c
    ./src/external/: retarget.cpp
    ./: main.cpp
  group global_macros
    ./src/global_macros/: global_macros.h qt_global_macros.h stm32f4xx_global_macros.h
  group spl4
    ./src/spl4/src/: misc.c stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_usart.c
    ./src/spl4/: stm32f4xx_conf.h
  group pin_setup
    ./src/pin_setup/: pin_setup.h pin_setup.cpp
  group time_service
    ./src/time_service/: time_service.h time_service.cpp
  group adc
    ./src/adc/: adc.h adc.cpp
  group dma
    ./src/dma/: dma.h dma.cpp
  group usart6
    ./src/usart6/: usart6.h usart6.cpp
  group soft
    ./src/soft/: soft_i2c.h soft_i2c.cpp
  group IRLocator
    ./src/irLocator/: IRLocator.h
    ./src/IRLocator/: IRLocator.cpp
  group motor
    ./src/motor/: motor.cpp motor.h
  group Motor_Pin_setup
    ./src/motor_pin_setup/: Motor_Pin.cpp Motor_Pin.h
  group motors
    ./src/motors/: motors.h motors.cpp
  group line_sensors
    ./src/line_sensors/: line_sensors.h line_sensors.cpp
  group ball_detecter
    ./src/ball_detecter/: ball_detecter.h ball_detecter.cpp
  group usart3
    ./src/usart3/: usart3.h usart3.cpp
  group OpenMV
    ./src/OpenMV/: OpenMV.h OpenMV.cpp
  group dist_sen
    ./: dist_sen.cpp dist_sen.h
  group my_math
    ./src/my_math/: my_math.h my_math.cpp
  group PID
    ./src/PID/: PID.h PID.cpp
  group Position
    ./src/Position/: Position.h Position.cpp
