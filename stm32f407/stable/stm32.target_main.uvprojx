# Keil uVision project stm32.target_main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE="12000000" STM32F40_41xxx USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: ./src/IRLocator;./src/adc;./src/cmsis;./src/dma;./src/external;./src/global_macros;./src/main;./src/motor;./src/motor_pin_setup;./src/motors;./src/odom;./src/pin_setup;./src/soft;./src/spl4;./src/spl4/inc;./src/spl4/src;./src/support_pacage;./src/support_pacage/arm;./src/support_pacage/gcc;./src/support_pacage/inc;./src/time_service;./src/usart6;C:/Keil_v5/ARM/CMSIS/Include
  asm include: :/Keil_v5/ARM/CMSIS/Include
  memory RVCT4: RAM 0x8000000 size 0x100000
  memory RVCT9: ROM 0x20000000 size 0x20000
  memory RVCT10: ROM 0x10000000 size 0x10000
  scatter file: ./stm32.target main.sct
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group main
    ./src/main/: RTE_Device.h startup_stm32f407xx.s project_config.h
    ./src/support_pacage/: system_stm32f4xx.c
    ./src/external/: retarget.cpp
    ./: main.cpp
  group global_macros
    ./src/global_macros/: global_macros.h qt_global_macros.h stm32f4xx_global_macros.h
  group spl4
    ./src/spl4/src/: misc.c stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_usart.c
    ./src/spl4/: stm32f4xx_conf.h
  group pin_setip
    ./src/pin_setup/: pin_setup.h pin_setup.cpp
  group time_service
    ./src/time_service/: time_service.h time_service.cpp
  group adc
    ./src/adc/: adc.h adc.cpp
  group dma
    ./src/dma/: dma.h dma.cpp
  group usart6
    ./src/usart6/: usart6.h usart6.cpp
  group soft
    ./src/soft/: soft_i2c.h soft_i2c.cpp
  group IRLocator
    ./src/irLocator/: IRLocator.h
    ./src/IRLocator/: IRLocator.cpp
  group motor
    ./src/motor/: motor.cpp motor.h
  group Motor_Pin_setup
    ./src/motor_pin_setup/: Motor_Pin.cpp Motor_Pin.h
  group odom
    ./src/odom/: odom.cpp odom.h
  group motors
    ./src/motors/: motors.cpp motors.h
